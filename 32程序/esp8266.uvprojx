# Keil uVision project esp8266.uvprojx, settings and files
target ESP8266 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: esp8266 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: .\User;.\lib\CMSIS\startup;.\lib\FWlib\inc;C:\Keil_v5\ARM\ARMCC\include;.\lib\CMSIS;.\system\头文件;.\main;.\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group main
    ./lib/CMSIS/: system_stm32f10x.c
    ./lib/CMSIS/startup/: startup_stm32f10x_hd.s
    ./main/: main.c stm32f10x_it.c
  group user
    ./lib/CMSIS/: core_cm3.c
    ./User/: oled.c 202.c timer.c esp8266.c
  group system
    ./system/: bsp_usart1.c Common.c delay.c sys.c
  group lib
    ./lib/FWlib/src/: misc.c stm32f10x_gpio.c stm32f10x_sdio.c stm32f10x_tim.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_dac.c stm32f10x_dma.c stm32f10x_exti.c
